
KERNEL_DEVICETREE ?= "tegra210-p3448-0002-p3449-0000-a02.dtb tegra210-p3448-0002-p3449-0000-b00.dtb"
